FILESEXTRAPATHS_prepend := "${THISDIR}/features:"
SRC_URI_append = " \
   file://enable-r8169-rt.cfg \
"
